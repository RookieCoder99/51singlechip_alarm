# Keil uVision project DS18b20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS18b20 +hex
  c flags: Optimize=8
  group Source Group 1
    ./: delay.c main.c ds1302.c IIC.c ds18b20.c hb.c yuyin.c alarm.c switch_screen.c main2233.c
